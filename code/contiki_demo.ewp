# IAR project contiki_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; Contiki\core; Contiki\core\sys; Contiki\core\lib; Contiki\core\net; Contiki\apps\shell; Contiki\apps\serial-shell; MiddleWare\; MiddleWare\contiki; MiddleWare\fs; User\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Link Files\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Contiki
    Contiki/core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group Contiki/apps/serial-shell
    Contiki/apps/serial-shell/: serial-shell.c serial-shell.h
  group Contiki/apps/shell
    Contiki/apps/shell/: shell-coffee.c shell-coffee.h shell-file.c shell-file.h shell-ps.c shell-ps.h shell-text.c shell-text.h shell.c shell.h
  group Contiki/core/cfs
    Contiki/core/cfs/: cfs-coffee.c cfs-coffee.h cfs.h
  group Contiki/core/dev
    Contiki/core/dev/: radio.h serial-line.c serial-line.h
  group Contiki/core/lib
    Contiki/core/lib/: list.c list.h me.c me.h me_tabs.c me_tabs.h memb.c memb.h mmem.c mmem.h random.c random.h ringbuf.c ringbuf.h
  group Contiki/core/net
    Contiki/core/net/: linkaddr.c linkaddr.h nbr-table.c nbr-table.h netstack.c netstack.h packetbuf.c packetbuf.h queuebuf.c queuebuf.h
  group Contiki/core/net/ip
    Contiki/core/net/ip/: dhcpc.c dhcpc.h psock.c psock.h resolv.c resolv.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcp-socket.c tcp-socket.h tcpip.c tcpip.h udp-socket.c udp-socket.h uip-debug.c uip-debug.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip_arch.h uiplib.c uiplib.h uipopt.h
  group Contiki/core/net/ipv4
    Contiki/core/net/ipv4/: uaodv-def.h uaodv-rt.c uaodv-rt.h uaodv.c uaodv.h uip-fw-drv.c uip-fw-drv.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-over-mesh.c uip-over-mesh.h uip.c uip_arp.c uip_arp.h
  group Contiki/core/net/ipv6
    Contiki/core/net/ipv6/: sicslowpan.c sicslowpan.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip6.c
  group Contiki/core/net/ipv6/multicast
    Contiki/core/net/ipv6/multicast/: roll-tm.c roll-tm.h smrf.c smrf.h uip-mcast6-engines.h uip-mcast6-route.c uip-mcast6-route.h uip-mcast6-stats.c uip-mcast6-stats.h uip-mcast6.h
  group Contiki/core/net/llsec
    Contiki/core/net/llsec/: nullsec.c nullsec.h
  group Contiki/core/net/mac
    Contiki/core/net/mac/: csma.c csma.h frame802154.c frame802154.h framer-802154.c framer-802154.h framer-nullmac.c framer-nullmac.h framer.c framer.h mac-sequence.c mac-sequence.h mac.c mac.h nullmac.c nullmac.h nullrdc-noframer.c nullrdc-noframer.h nullrdc.c nullrdc.h phase.c phase.h rdc.h
  group Contiki/core/net/rpl
    Contiki/core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group Contiki/core/sys
    Contiki/core/sys/: arg.c arg.h autostart.c autostart.h cc.h clock.h compower.c compower.h ctimer.c ctimer.h dsc.h energest.c energest.h etimer.c etimer.h lc-addrlabels.h lc-switch.h lc.h loader.h log.h mt.c mt.h node-id.h process.c process.h procinit.c procinit.h pt-sem.h pt.h rtimer.c rtimer.h stimer.c stimer.h subprocess.h timer.c timer.h
  group MiddleWare/contiki
    MiddleWare/contiki/: contiki_clock.c mtarch.h rtimer-arch.c rtimer-arch.h stm32_def.h
  group MiddleWare/devs/serial
    MiddleWare/devs/serial/: stm32f1xx_serial.c stm32f1xx_serial.h
  group MiddleWare/devs/spi
    MiddleWare/devs/spi/: rhb_spi_bus_adapter.c rhb_spi_bus_adapter.h
  group MiddleWare/devs/watchdog
    MiddleWare/devs/watchdog/: watchdog.c
  group MiddleWare/fs
    MiddleWare/fs/: cfs-coffee-arch.c cfs-coffee-arch.h
  group MiddleWare/hal/arch/inc
    MiddleWare/hal/arch/inc/: arch_io_dma.h arch_io_ethernet.h arch_io_exti.h arch_io_flash.h arch_io_gpio.h arch_io_ints.h arch_io_memmap.h arch_io_rcc.h arch_io_reg.h arch_io_sdio.h arch_io_spi.h arch_io_usart.h
  group MiddleWare/hal/arch/src
    MiddleWare/hal/arch/src/: arch_io_dma.c arch_io_ethernet.c arch_io_exti.c arch_io_flash.c arch_io_gpio.c arch_io_rcc.c arch_io_sdio.c arch_io_spi.c arch_io_usart.c
  group MiddleWare/hal/CortexM3
    MiddleWare/hal/CortexM3/: hal_io_asm.asm hal_io_ints.c hal_io_ints.h hal_io_level.h
  group MiddleWare/infra
    MiddleWare/infra/: rhb_type.h
  group MiddleWare/net
    MiddleWare/net/: at86rf21x_drv.h at86rf21x_drv_ext.c at86rf23x_drv.h at86rf23x_drv_ext.c contiki_net_init.c contiki_net_init.h
  group MiddleWare/runtime
    MiddleWare/runtime/: low_level_init.c time.c time64.c uartstdio.c uartstdio.h
  group MiddleWare/services
    MiddleWare/services/: sys_services.c sys_services.h
  group Startup
    Startup/: startup_stm32f10x_cl.c startup_stm32f10x_hd.c startup_stm32f10x_ld.c startup_stm32f10x_md.c
  group User
    User/: bsm.c bsm.h contiki-conf.h contiki-net-conf.h globalmacro.h includes.h Main.c Main.h moteid.c moteid.h radio_para.c radio_para.h usr_framer.c usr_framer.h usr_mac.c usr_mac.h
